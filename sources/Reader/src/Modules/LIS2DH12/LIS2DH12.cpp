// 2022/6/24 15:52:26 (c) Aleksandr Shevchenko e-mail : Sasha7b9@tut.by
#include "defines.h"
#include "Modules/LIS2DH12/LIS2DH12.h"
#include "Modules/LIS2DH12/LIS2DH12_reg.h"
#include "Hardware/HAL/HAL.h"
#include "Hardware/HAL/HAL_PINS.h"
#include "Hardware/Timer.h"
#include "Modules/Player/Player.h"
#include "Modules/Indicator/Indicator.h"
#include "Modules/Player/Player.h"
#include "Device/Device.h"
#include "Communicator/OSDP.h"
#include "Utils/Averager.h"
#include "Utils/FiltrMiddleOf3.h"
#include "Modules/Memory/Memory.h"
#include "Utils/Math.h"
#include "Reader/Reader.h"
#include "system.h"
#include <cstring>
#include <cstdio>


namespace LIS2DH12 
{
    static const uint8 ADDRESS = 0x19 << 1;

    static StructDataRaw raw_temp;

    static AveragerRaw<StructDataRaw, 1> raw_acce_x;       // /
    static AveragerRaw<StructDataRaw, 1> raw_acce_y;       // | текущие значения акселерометра
    static AveragerRaw<StructDataRaw, 1> raw_acce_z;       // /

    static AveragerRaw<StructDataRaw, 1> *raw_1 = nullptr;     // Здесь будет наименьшая измеренная ось
    static AveragerRaw<StructDataRaw, 1> *raw_2 = nullptr;     // Здесь будет вторая по величине измеренная ось

    static bool Write(uint8 reg, uint8 data)
    {
        return HAL_I2C::Write(ADDRESS, reg, &data, 1);
    }

    static uint8 Read(uint8 reg)
    {
        uint8 result = 0;
        HAL_I2C::Read(ADDRESS, reg, &result, 1);
        return result;
    }

    // Сторож
    namespace Watcher
    {
        static StructDataRaw start_x;       // /
        static StructDataRaw start_y;       // | Это стартовые значения - с ними будем сравнивать
        static StructDataRaw start_z;       // /

        static StructDataRaw *start_1 = nullptr;    // Указатель на минимальную измеренную ось
        static StructDataRaw *start_2 = nullptr;    // Указатель на вторую по величине измеренную ось

        static bool is_init = false;

        static bool is_alarmed = false;                 // Положение изменилось. Гудим
        static TimeMeterMS meter_duration_alarm;        // Здесь - время, которое прошло с начала последней тревоги
        static TimeMeterMS meter_after_disable_alarm;   // Столько времени прошло с отключения последней тревоги


        static void Init()
        {
            is_init = true;

            start_x = raw_acce_x.Get();
            start_y = raw_acce_y.Get();
            start_z = raw_acce_z.Get();

            float x = start_x.ToAccelearation();
            float y = start_y.ToAccelearation();
            float z = start_z.ToAccelearation();

            if (x <= y && x <= z)
            {
                start_1 = &start_x;
                raw_1 = &raw_acce_x;

                start_2 = (y <= z) ? &start_y : &start_z;
                raw_2 = (y <= z) ? &raw_acce_y : &raw_acce_z;
            }
            else if (y <= x && y <= z)
            {
                start_1 = &start_y;
                raw_1 = &raw_acce_y;

                start_2 = (x <= z) ? &start_x : &start_z;
                raw_2 = (x <= z) ? &raw_acce_x : &raw_acce_z;
            }
            else
            {
                start_1 = &start_z;
                raw_1 = &raw_acce_z;

                start_2 = (x <= y) ? &start_x : &start_y;
                raw_2 = (x <= y) ? &raw_acce_x : &raw_acce_y;
            }
        }

        static void Update()
        {
            if (meter_after_disable_alarm.ElapsedMS() < 5000)
            {
                return;
            }

            if (ModeReader::IsExtended())
            {
                return;
            }

            if (!gset.IsEnabledAntibreak())
            {
                return;
            }

//            volatile float delta = gset.GetAntibreakSens();

            float angle = 0.0f;

            if (raw_1)
            {
                bool result = true;

                angle = std::fabsf(start_1->ToAccelearation() - raw_1->Get().ToAccelearation());

                static FiltrMiddleOf3<float> middle_angle;

                if (result)     //-V547     // \todo Здесь какая-то дичь. Всегда true
                {
                    angle = middle_angle.Push(angle);
                }
                else
                {
                    if (!is_alarmed)
                    {
                        return;
                    }
                }

                if (is_alarmed)
                {
                    Indicator::Blink(Color(0xFFFFFFFF, 1.0f), Color(0x00000000, 0.0f), 1, true);

                    Player::PlayFromMemory(gset.Melody(TypeSound::Beep), 3);

                    while (Indicator::IsRunning())
                    {
                        Device::UpdateTasks();
                    }

                    if (meter_duration_alarm.ElapsedMS() > 30 * 1000)
                    {
                        is_alarmed = false;
                        is_init = false;
                        meter_after_disable_alarm.Reset();
                        raw_1 = nullptr;
                        Indicator::Reset();
                    }

                    return;
                }
            }

            if (!is_init)
            {
                Init();

                return;
            }

            if (angle > 0.05f)
            {
                is_alarmed = true;
                meter_duration_alarm.Reset();

                uint number = gset.GetAntibreakNumber();

                if (OSDP::IsEnabled())
                {
                    OSDP::AntibreakAlarm();
                }
                else if (ModeReader::IsWG())
                {
                    Block4 block{ number };

                    HAL_USART::WG::Transmit(block.bytes[2], block.bytes[1], block.bytes[0]);
                }
            }
        }
    }
}


bool LIS2DH12::IsAlarmed()
{
    return Watcher::is_alarmed;
}


void LIS2DH12::Init()
{
    pinIRQ_SNS.Init();

    uint8 data = 0;
    _SET_BIT(data, 4);                              // I1_ZYXDA = 1 - разрешаем прерывания INT1 по полученным измерениям
    Write(LIS2DH12_CTRL_REG3, data);

    // Enable Block Data Update.
    data = Read(LIS2DH12_CTRL_REG4);
    data |= (1 << 7);                               // BDU = 1
    Write(LIS2DH12_CTRL_REG4, data);

    // Set Output Data Rate to 1Hz.
    HAL_I2C::Read(ADDRESS, LIS2DH12_CTRL_REG1, &data, 1);
    data |= (1 << 4);                               // ODR = 0b0001, 1Hz
    HAL_I2C::Write(ADDRESS, LIS2DH12_CTRL_REG1, &data, 1);
    
 // Set full scale to 2g.
 // lis2dh12_full_scale_set(&dev_ctx, LIS2DH12_2g);   Это значение по умолчанию

    // Enable temperature sensor.
    data = 0xC0;
    HAL_I2C::Write(ADDRESS, LIS2DH12_TEMP_CFG_REG, &data, 1);     // TEMP_EN = 0b11

    // Set device in continuous mode with 12 bit resol.
    HAL_I2C::Read(ADDRESS, LIS2DH12_CTRL_REG4, &data, 1);

    data |= (1 << 3);                                           // HR = 1, (LPen = 0 - High resolution mode)

    Write(LIS2DH12_CTRL_REG4, data);
}


void LIS2DH12::Update()
{
    if (HAL::Is765() || Player::IsPlaying())
    {
        return;
    }

    if (pinIRQ_SNS.IsHi())                                      // ZYXDA
    {
        static FiltrMiddleOf3<int16> middleX;
        static FiltrMiddleOf3<int16> middleY;
        static FiltrMiddleOf3<int16> middleZ;

        if (Read(LIS2DH12_STATUS_REG) & (1 << 3))
        {
            StructDataRaw data;

            ////////////////////////////////////////

            data.lo = Read(LIS2DH12_OUT_X_L);
            data.hi = Read(LIS2DH12_OUT_X_H);

            data.raw = middleX.Push(data.raw);

            raw_acce_x.Push(data);

            ////////////////////////////////////////

            data.lo = Read(LIS2DH12_OUT_Y_L);
            data.hi = Read(LIS2DH12_OUT_Y_H);

            data.raw = middleY.Push(data.raw);

            raw_acce_y.Push(data);

            ///////////////////////////////////////

            data.lo = Read(LIS2DH12_OUT_Z_L);
            data.hi = Read(LIS2DH12_OUT_Z_H);

            data.raw = middleZ.Push(data.raw);

            raw_acce_z.Push(data);

            //////////////////////////////////////

            Watcher::Update();
        }
    }

    if (Read(LIS2DH12_STATUS_REG_AUX) & (1 << 2))       // TDA
    {
        raw_temp.lo = Read(LIS2DH12_OUT_TEMP_L);
        raw_temp.hi = Read(LIS2DH12_OUT_TEMP_H);
    }
}


float LIS2DH12::GetTemperature()
{
    return raw_temp.ToTemperatrue();
}
