# Keil uVision project Reader-771.uvprojx, settings and files
target Release (6210000::V6.21::ARMCLANG)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RD3304-771 +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xB, ARM_MATH_CM4, TYPE_BOARD_771
  c include: .\src;.\src\Hardware\HAL\STM;.\src\Hardware\CDC;..\common\STM32Cube_F1\Drivers\STM32F1xx_HAL_Driver\Inc;..\common\STM32Cube_F1\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\STM32Cube_F1\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\STM32Cube_F1\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\common\STM32Cube_F1\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Reader-20kB.sct
  group STM32F1
    ../common/STM32Cube_F1/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group src
    ./src/: opt.h main.cpp defines.h
  group Communicator
    ./src/Communicator/: AnswersOSDP.cpp AnswersOSDP.h Communicator.cpp Communicator.h OSDP.cpp OSDP.h ROMWriter.cpp ROMWriter.h OSDP_custom.cpp
  group Deivce
    ./src/Device/: Device.cpp Device.h DeviceInfo.cpp DeviceStartState.cpp
  group Hardware
    ./src/Hardware/: Timer.h Power.cpp Power.h Timer.cpp
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f103xb.s system_stm32f1xx.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL_PINS.h HAL_FLASH.cpp HAL_ROM.cpp HAL_USART.cpp HAL_USART_opt.cpp
    ./src/Hardware/HAL/STM/: HAL_ADC_stm.cpp HAL_I2C_stm.cpp HAL_IT_stm.cpp HAL_PINS_stm.cpp HAL_ROM_stm.cpp HAL_SPI_stm.cpp stm32f1xx_hal_conf.h HAL_stm.cpp
  group Modules/Indicator
    ./src/Modules/Indicator/: Indicator.cpp Indicator.h IndicatorTask.cpp ColorLED.h SwitchTemperatureIndicator.cpp SwitchTemperatureIndicator.h
  group Modules/Indicator/LP5012
    ./src/Modules/Indicator/LP5012/: DriverLP5012.cpp LP5012.cpp LP5012.h
  group Modules/Indicator/Scripts
    ./src/Modules/Indicator/Scripts/: ScriptsLED.cpp ScriptsLED.h StepScript.cpp StepScript.h
  group Modules/LIS2DH12
    ./src/Modules/LIS2DH12/: LIS2DH12.cpp LIS2DH12.h LIS2DH12_reg.h
  group Modules/Player
    ./src/Modules/Player/: BeeperTask.cpp Player.h Sounds.h TableSounds.h
    ./src/Modules/Player/STM/: Player_stm.cpp Sounds_stm.cpp
  group Modules/Memory
    ./src/Modules/Memory/: Memory.cpp Memory.h
  group Reader
    ./src/Reader/: Reader.cpp Reader.h Events.cpp Events.h Signals.cpp Signals.h
  group Reader/Cards
    ./src/Reader/Cards/: AES.cpp AES.h Card.cpp Card.h Card14443.cpp CardMF.cpp CardMF.h CardMFC.cpp CardMFP.cpp CardNTAG.cpp CardNTAG.h CardsEntities.h transf.py TypeCard.cpp TypeCard.h CardHiLvl.cpp CardTasks.cpp CardTasks.h
  group Reader/RC663
    ./src/Reader/RC663/: Commands.cpp Commands.h LPCD.cpp LPCD.h RC663.cpp RC663.h RC663_def.h Registers.cpp Registers.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h SettingsTypes.h SET2.cpp SET2.h
  group Utils
    ./src/Utils/: Buffer.h Mutex.h StringUtils.h StringUtils.cpp Log.cpp Log.h String.h Math.cpp Math.h Debug.cpp Debug.h RingBuffer.cpp RingBuffer.h Averager.h FiltrMiddleOf3.h Hysteresis.h StackFILO.h
target Debug (6210000::V6.21::ARMCLANG)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: RD3304-771D +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xB, ARM_MATH_CM4, TYPE_BOARD_771, DEBUG
  c include: .\src;.\src\Hardware\HAL\STM;..\common\STM32Cube_F1\Drivers\STM32F1xx_HAL_Driver\Inc;..\common\STM32Cube_F1\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\STM32Cube_F1\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\STM32Cube_F1\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\common\STM32Cube_F1\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Reader-20kB.sct
