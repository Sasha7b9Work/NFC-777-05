# Keil uVision project Demo-799.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: GD32E230K8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=2
  c define: GD32E230, TYPE_BOARD_799, DEBUG
  c include: .\src;.\src\Hardware\HAL\GD;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x\Include;..\common\GD32E23x_Firmware_Library\Firmware\GD32E23x_standard_peripheral\Include;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x
  memory RVCT4: ROM 0x8000000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Reader-8kB.sct
  group GD32E23x
    ../common/GD32E23x_Firmware_Library/Firmware/GD32E23x_standard_peripheral/Include/: gd32e23x_adc.h gd32e23x_cmp.h gd32e23x_crc.h gd32e23x_dbg.h gd32e23x_dma.h gd32e23x_exti.h gd32e23x_fmc.h gd32e23x_fwdgt.h gd32e23x_gpio.h gd32e23x_i2c.h gd32e23x_misc.h gd32e23x_pmu.h gd32e23x_rcu.h gd32e23x_rtc.h gd32e23x_spi.h gd32e23x_syscfg.h gd32e23x_timer.h gd32e23x_usart.h gd32e23x_wwdgt.h
    ../common/GD32E23x_Firmware_Library/Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_misc.c gd32e23x_gpio.c gd32e23x_rcu.c gd32e23x_i2c.c gd32e23x_spi.c gd32e23x_dma.c gd32e23x_usart.c gd32e23x_exti.c gd32e23x_syscfg.c
  group src
    ./src/: opt.h main.cpp system.h defines.h
  group Communicator
    ./src/Communicator/: AnswersOSDP.cpp AnswersOSDP.h Communicator.cpp Communicator.h OSDP.cpp OSDP.h ROMWriter.cpp ROMWriter.h OSDP_custom.cpp
  group Deivce
    ./src/Device/: Device.h DeviceInfo.cpp DeviceStartState.cpp
    ./vs_keilDemo799/Device/: Device_demo.cpp
  group Hardware
    ./src/Hardware/: Timer.h Power.cpp Power.h Timer.cpp
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_gd32e23x.s system_gd32e23x.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL_PINS.h HAL_FLASH.cpp HAL_ROM.cpp HAL_USART.cpp HAL_USART_opt.cpp
    ./src/Hardware/HAL/GD/: gd32e23x_libopt.h HAL_ADC_gd.cpp HAL_I2C_gd.cpp HAL_PINS_gd.cpp HAL_ROM_gd.cpp HAL_SPI_gd.cpp HAL_IT_gd.cpp systick.h systick.cpp HAL_gd.cpp HAL_I2S.cpp HAL_TIM5_gd.cpp HAL_TIM13_gd.cpp HAL_IT_PB2_gd.cpp
  group Modules/Indicator
    ./src/Modules/Indicator/: Indicator.h IndicatorTask.cpp ColorLED.h SwitchTemperatureIndicator.cpp SwitchTemperatureIndicator.h
    ./vs_keilDemo799/Modules/Indicator/: Indicator_demo.cpp
  group Modules/Indicator/Scripts
    ./src/Modules/Indicator/Scripts/: ScriptsLED.h StepScript.cpp StepScript.h
    ./vs_keilDemo799/Modules/Indicator/Scripts/: ScriptsLED_demo.cpp
  group Modules/Indicator/WS2812B
    ./src/Modules/Indicator/WS2812B/: WS2812B.cpp WS2812B.h
  group Modules/LIS2DH12
    ./src/Modules/LIS2DH12/: LIS2DH12.cpp LIS2DH12.h LIS2DH12_reg.h
  group Modules/Memory
    ./src/Modules/Memory/: Memory.cpp Memory.h
  group Modules/Player
    ./src/Modules/Player/: BeeperTask.cpp Player.h TableSounds.h
    ./src/Modules/Player/GD/: Player_gd.cpp
  group Modules/Sensor
    ./src/Modules/Sensor/: TTP223.cpp TTP223.h
  group Reader
    ./src/Reader/: Reader.cpp Reader.h Events.cpp Events.h Signals.cpp Signals.h
  group Reader/Cards
    ./src/Reader/Cards/: AES.cpp AES.h Card.h Card.cpp CardHiLvl.cpp Card14443.cpp CardMF.cpp CardMF.h CardMFC.cpp CardMFP.cpp CardNTAG.cpp CardNTAG.h CardsEntities.h transf.py TypeCard.cpp TypeCard.h CardTasks.cpp CardTasks.h
  group Reader/RC663
    ./src/Reader/RC663/: Commands.cpp Commands.h LPCD.cpp LPCD.h RC663.h RC663_def.h Registers.cpp Registers.h
    ./vs_keilDemo799/Reader/RC663/: RC663_demo.cpp
  group Settings
    ./src/Settings/: Settings.cpp Settings.h SettingsTypes.h SET2.cpp SET2.h
  group Utils
    ./src/Utils/: Buffer.h Mutex.h StringUtils.h StringUtils.cpp Log.cpp Log.h String.h Math.cpp Math.h Debug.cpp Debug.h RingBuffer.cpp RingBuffer.h Averager.h FiltrMiddleOf3.h Hysteresis.h StackFILO.h
target Release (6210000::V6.21::ARMCLANG)
  device: GD32E230K8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: as above
  output: Demo +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=2
  c define: GD32E230, TYPE_BOARD_799
  c include: .\src;.\src\Hardware\HAL\GD;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x\Include;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x;..\common\GD32E23x_Firmware_Library\Firmware\GD32E23x_standard_peripheral\Include
  memory RVCT4: ROM 0x8000000 size 0xe800
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Reader-8kB.sct
