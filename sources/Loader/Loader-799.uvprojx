# Keil uVision project Loader-799.uvprojx, settings and files
target Release (6210000::V6.21::ARMCLANG)
  device: GD32E230K8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Loader799 +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 v6Lto=1 wLevel=2
  c define: GD32E230
  c include: .\src\Hardware\HAL;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x\Include;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x;..\common\GD32E23x_Firmware_Library\Firmware\GD32E23x_standard_peripheral\Include;.\src
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group GD32E23x
    ../common/GD32E23x_Firmware_Library/Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_misc.c gd32e23x_gpio.c gd32e23x_rcu.c gd32e23x_fmc.c
  group src
    ./src/: fmw.h config.h booter_crc.h Update.h Utils.h booter_aes.h main.cpp booter_crc.cpp fmw.cpp Update.cpp Utils.cpp booter_aes.cpp
  group Hardware
    ./src/Hardware/: systick.h systick.cpp hrd_Iap.cpp hrd_Iap.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_gd32e23x.s system_gd32e23x.c
  group Hardware/HAL
    ./src/Hardware/HAL/: gd32e23x_libopt.h HAL.cpp HAL.h HAL_PINS.cpp HAL_PINS.h HAL_SPI.cpp
